## config/Kconfig.shield
```kconfig
# Copyright (c) 2022 Palmtree Studios
# SPDX-License-Identifier: MIT

config SHIELD_CODEMONKEY
	def_bool $(shields_list_contains,codemonkey)
```
